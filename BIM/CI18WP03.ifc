Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-05-21T13:38:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Zastępczy Interfejs Użytkownika 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri May 21 13:38:10 2021 * Host: WAWWCW00717 * Database: C:\Users\kowalikk\AppData\Local\Temp\32391897-db1a-4076-a2ad-409cbf5ba400\eb87536f-f6f1-4141-becc-311ecbd04bb9\ifc * Database version: 5507 * Database creation date: Fri May 21 13:38:07 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri May 21 13:38:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri May 21 13:38:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 0
